COMPATIBLE_MACHINE:de0nano-litex = "invalid"